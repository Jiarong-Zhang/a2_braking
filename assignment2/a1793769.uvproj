# Keil uVision project a1793769.uvproj, settings and files
target C167CR-LM (166/167)
  device: C167CR-LM Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xE000-0xE7FF) ICAN(0xE800-0xEFFF) CLOCK(20000000) MOD167
  output: a1793769
  group Source
    ./Source/: encoder.h main.c encoder.c lidar.c lidar.h buffer.c buffer.h calculations.c calculations.h
  group Drivers
    ./Drivers/: adc.c adc.h aeb.h gpio.c gpio.h interrupt.h template.h aeb.c timer.c timer.h platform.h dac.c
